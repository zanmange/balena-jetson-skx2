FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Add-requested-headers-to-the-archive-for-NVidia-Jets.patch"
