RDEPENDS_${PN} += " \
    tegra-firmware-xusb \
    tegra-firmware \
    "
